FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-set-correct-rt-module-name.patch"
