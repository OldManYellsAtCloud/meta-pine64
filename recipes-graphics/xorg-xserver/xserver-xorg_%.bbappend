DEPENDS += "libxshmfence"
RDEPENDS:${PN} += "xf86-video-modesetting xserver-xf86-config"
