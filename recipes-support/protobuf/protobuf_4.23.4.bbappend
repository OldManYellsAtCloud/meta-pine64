# https://github.com/openembedded/meta-openembedded/commit/b1deec0de476d8f0a0c6427919f57ee5f681ea0e
SYSROOT_DIRS += "${bindir}"
