FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://fix-sigsegv.patch"
