PACKAGECONFIG += "ofono systemd"
EXTRA_OECONF += "--disable-static"
