FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://i2c.cfg"
SRC_URI += "file://base64.cfg"
PR = "r02"
