PACKAGECONFIG:append = " imap pop3 smtp "
