QT_QPA_DEFAULT_PLATFORM = "wayland"
PACKAGECONFIG:append = " sql-sqlite "
